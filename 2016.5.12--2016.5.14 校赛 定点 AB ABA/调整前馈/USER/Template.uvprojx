# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F427VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,USE_STM324x7I_EVAL,__FPU_PRESENT,EMPL_TARGET_STM32F4,MPU9150,ARM_MATH_CM4
  c misc: --C99
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE;..\CORE;..\FWLIB\src;..\USER;..\FWLIB\inc;..\HARDWARE\NRF;..\HARDWARE\mpu;..\HARDWARE\camera
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
    ../HARDWARE/: scheduler.c
  group CORE
    ../CORE/: startup_stm32f427_437xx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_crc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_dma.c stm32f4xx_i2c.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_dcmi.c stm32f4xx_adc.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../HARDWARE/: systick.c
    ../SYSTEM/usart/: usart.c
  group README
    ../README/: README.txt
  group HARDWARE
    ../HARDWARE/: oled.c led.c pwm.c key.c csb.c ANO_DT.c struct.c pid.c timer.c filter.c fly.c menu.c adc.c
  group MPU
    ../HARDWARE/mpu/: i2c.c gpio.c inv_mpu.c inv_mpu_user.c sen_data_build.c inv_mpu_dmp_motion_driver.c
  group CAMERA
    ../HARDWARE/camera/: dcmi.c image.c OV7620.c sccb.c
  group NRF
    ../HARDWARE/NRF/: nrf24l01_usart.c usart_dma.c
